Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Ostnor
Time: 2008-09-22T09:37:19
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: FM Mattson 8005-0000, 8005-0000:FM Mattson 8005-0000:FM Mattson 8005-0000:108400
In: Level 1
PSet_Revit_Dimensions - Counter Height: 900 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 4
PSet_Revit_Type_Identity Data - URL: www.fmmattsson.com; RSK: 830 88 81; Model: 8005-0000; Manufacturer: FM Mattson; Family: 9000E; Description: FMM Kitchen Mixer 9000E II with handshower
